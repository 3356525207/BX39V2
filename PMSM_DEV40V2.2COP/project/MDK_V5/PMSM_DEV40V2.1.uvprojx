# Keil uVision project PMSM_DEV40V2.1.uvprojx, settings and files
target PMSM_DEV40V2.1 (6240000::V6.24::ARMCLANG)
  device: AT32M412CBT7 ArteryTek
  pack: ArteryTek.AT32M412_416_DFP.2.0.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PMSM_DEV40V2.1 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32M412CBT7, USE_STDPERIPH_DRIVER, ARM_MATH_CM4, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, ARM_MATH_LOOPUNROLL
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\MY_App\CAN;..\..\MY_App\MotorControl;..\..\MY_App\Global_control;..\..\MY_App\FLASH;../../libraries/cmsis/dsp/include;../../libraries/cmsis/dsp/PrivateInclude
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../../MY_APP/Global_control/: global_control.c
    ../src/: at32m412_416_int.c at32m412_416_wk_config.c main.c wk_system.c wk_adc.c wk_tmr.c wk_gpio.c wk_usart.c wk_dma.c wk_spi.c
    ../../MY_APP/CAN/: vofa.c UART_CAN.c
    ../../MY_APP/MotorControl/: ADC_front-end.c Encoder.c foc_drv.c math_drv.c
    ../../MY_App/MotorControl/: motor_sensoruse.c HKT7823.c kth78xx.c thermistor.c luenberger_observer.c ADRC.c PID.c step_counter.c
    ../../MY_App/FLASH/: flash.c
  group firmware
    ../../libraries/drivers/src/: at32m412_416_crm.c at32m412_416_tmr.c at32m412_416_gpio.c at32m412_416_usart.c at32m412_416_pwc.c at32m412_416_adc.c at32m412_416_spi.c at32m412_416_dma.c at32m412_416_debug.c at32m412_416_flash.c at32m412_416_misc.c at32m412_416_wdt.c
  group cmsis
    ./: startup_at32m412_416.s
    ../../libraries/cmsis/cm4/device_support/: system_at32m412_416.c
  group cmsis_dsp
    ../../libraries/cmsis/dsp/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../../libraries/cmsis/dsp/Source/BayesFunctions/: BayesFunctions.c
    ../../libraries/cmsis/dsp/Source/CommonTables/: CommonTables.c
    ../../libraries/cmsis/dsp/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../../libraries/cmsis/dsp/Source/ControllerFunctions/: ControllerFunctions.c
    ../../libraries/cmsis/dsp/Source/DistanceFunctions/: DistanceFunctions.c
    ../../libraries/cmsis/dsp/Source/FastMathFunctions/: FastMathFunctions.c
    ../../libraries/cmsis/dsp/Source/FilteringFunctions/: FilteringFunctions.c
    ../../libraries/cmsis/dsp/Source/InterpolationFunctions/: InterpolationFunctions.c
    ../../libraries/cmsis/dsp/Source/MatrixFunctions/: MatrixFunctions.c
    ../../libraries/cmsis/dsp/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../../libraries/cmsis/dsp/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../../libraries/cmsis/dsp/Source/SupportFunctions/: SupportFunctions.c
    ../../libraries/cmsis/dsp/Source/SVMFunctions/: SVMFunctions.c
    ../../libraries/cmsis/dsp/Source/TransformFunctions/: TransformFunctions.c
