# Keil uVision project LedBlink.uvprojx, settings and files
target N32G003 (5060960::V5.06 update 7 (build 960)::.\arm5)
  device: N32G003F5 Nationstech
  pack: Nationstech.N32G003_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0C00) IROM(0x08000000,0x7600) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LedBlink +hex
  AfterMake: fromelf --bin --output=.\bin\LedBlink.bin .\Objects\LedBlink.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G003, USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\core;..\CMSIS\device;..\inc;..\n32g003_std_periph_driver\inc;..\myapp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7200
  memory RVCT9: RAM 0x20000000 size 0xc00
  group STARTUP
    ../CMSIS/device/startup/: startup_n32g003.s
  group CMSIS
    ../CMSIS/device/: system_n32g003.c
    ../src/: n32g003_it.c
  group FWLB
    ../n32g003_std_periph_driver/src/: n32g003_gpio.c n32g003_rcc.c n32g003_tim.c n32g003_uart.c n32g003_iwdg.c n32g003_beeper.c misc.c n32g003_flash.c
  group USER
    ../src/: main.c bsp_led.c
    ../myapp/: aip1640.c RCV315.c SYS_RUN.c bt_transparent.c addr_store.c beep.c tim1.c uart_comm.c ctrl_tx.c sn_builder.c pairing_store.c
  group DELAY
    ../src/: bsp_delay.c
  group DOC
    ../: readme.txt
target N32G003_BenchTest (5060960::V5.06 update 7 (build 960)::.\arm5)
  device: N32G003F5 Nationstech
  pack: Nationstech.N32G003_DFP.1.0.0
  cpu: as above
  output: LedBlink_BenchTest +hex
  AfterMake: as above
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G003, USE_STDPERIPH_DRIVER, TEST_BYPASS_COMM_ERR
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7200
  memory RVCT9: RAM 0x20000000 size 0xc00
